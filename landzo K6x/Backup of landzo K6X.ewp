# IAR project Backup of landzo K6X.ewp, settings and files
configuration mk64f_Release (ARM)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; MK64F12; IAR
  ICCARM.CCIncludePath2: ..\src; ..\src\cpu; ..\src\App; ..\src\CMSIS; ..\src\CMSIS\Inc; ..\src\Driver; ..\src\Driver\adc; ..\src\Driver\can; ..\src\Driver\delay; ..\src\Driver\dma; ..\src\Driver\Flash; ..\src\Driver\FTM; ..\src\Driver\gpio; ..\src\Driver\i2c; ..\src\Driver\lptmr; ..\src\Driver\PIT; ..\src\Driver\SDHC; ..\src\Driver\spi; ..\src\Driver\system; ..\src\Driver\uart; ..\src\Driver\usb; ..\src\Driver\Wdog; $TOOLKIT_DIR$\inc; $TOOLKIT_DIR$\inc\Freescale; ..\src\landzo\Landzo_CCD; ..\src\landzo\Landzo_Electromagnetism; ..\src\landzo\Landzo_GyroAccelerate; ..\src\landzo\Landzo_Key; ..\src\landzo\Landzo_MeasureSpeed; ..\src\landzo\Landzo_Motor; ..\src\landzo\Landzo_OLED; ..\src\landzo\Landzo_Predator; ..\src\landzo\Landzo_SD; ..\src\landzo\Landzo_ServoMotor; ..\src\landzo\Landzo_Calculation
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: landzo K6X.srec
  ILINK.IlinkOutputFile: landzo K6X.out
  ILINK.IlinkIcfFile: ..\config files\linker\MK64xN1M_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration mk64f_Debug (ARM)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\config files\linker\MK64xN1M_ram.icf
configuration mk60dz_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: NDEBUG; MK60DZ10; IAR
  ICCARM.CCIncludePath2: ..\src; ..\src\cpu; ..\src\App; ..\src\CMSIS; ..\src\CMSIS\Inc; ..\src\Driver; ..\src\Driver\adc; ..\src\Driver\can; ..\src\Driver\delay; ..\src\Driver\dma; ..\src\Driver\Flash; ..\src\Driver\FTM; ..\src\Driver\gpio; ..\src\Driver\i2c; ..\src\Driver\lptmr; ..\src\Driver\PIT; ..\src\Driver\SDHC; ..\src\Driver\spi; ..\src\Driver\system; ..\src\Driver\uart; ..\src\Driver\usb; ..\src\Driver\Wdog; $TOOLKIT_DIR$\inc; $TOOLKIT_DIR$\inc\Freescale; ..\src\landzo\Landzo_CCD; ..\src\landzo\Landzo_Electromagnetism; ..\src\landzo\Landzo_GyroAccelerate; ..\src\landzo\Landzo_Key; ..\src\landzo\Landzo_MeasureSpeed; ..\src\landzo\Landzo_Motor; ..\src\landzo\Landzo_OLED; ..\src\landzo\Landzo_Predator; ..\src\landzo\Landzo_SD; ..\src\landzo\Landzo_ServoMotor; ..\src\landzo\Landzo_Calculation; ..\src\landzo\Landzo_Ultrasonic; ..\src\landzo\Landzo_1.44TFT; ..\src\landzo\Landzo_NRF24L01; ..\src\landzo\Landzo_TFTLCD
  ILINK.IlinkIcfFile: ..\config files\linker\MK60xN512_flash.icf
configuration mk60dz_Debug (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx12 Freescale MK60FX512xxx12
  ICCARM.CCDefines: NDEBUG; MK60DZ10; IAR
  ILINK.IlinkIcfFile: ..\config files\linker\MK60xN512_ram.icf
configuration mk60f_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  ICCARM.CCDefines: NDEBUG; MK60F15; IAR
  ILINK.IlinkIcfFile: ..\config files\linker\MK60xN512_flash.icf
configuration mk60f_Debug (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx12 Freescale MK60FX512xxx12
  ICCARM.CCDefines: NDEBUG; MK60DZ10; IAR
  ILINK.IlinkIcfFile: ..\config files\linker\MK60xN512_ram.icf
  group App
    ../src/App/: isr.c main.c
  group Driver
    ../src/Driver/adc/: K6x_adc.c
    ../src/Driver/CAN/: K6x_can.c
    ../src/Driver/delay/: K6x_delay.c
    ../src/Driver/dma/: K6x_dma.c
    ../src/Driver/Flash/: K6x_flash.c
    ../src/Driver/FTM/: K6x_FTM.c
    ../src/Driver/gpio/: K6x_gpio.c port.h
    ../src/Driver/i2c/: K6x_i2c.c
    ../src/Driver/lptmr/: K6x_lptmr.c
    ../src/Driver/PIT/: K6x_PIT.c
    ../src/Driver/SDHC/: K6x_sdhc.c
    ../src/Driver/spi/: K6x_spi.c
    ../src/Driver/uart/: K6x_uart.c
    ../src/Driver/Wdog/: K6x_wdog.c
  group Include
    ../src/cpu/: common.h include.h
    ../src/Driver/gpio/: pin_cfg.h
    ../src/Driver/system/: systemclock.h
  group Landzo module
    ../src/landzo/Landzo_1.44TFT/: Landzo_1.44TFT.c
    ../src/landzo/Landzo_Calculation/: Landzo_Calculation.c
    ../src/landzo/Landzo_CCD/: Landzo_CCD.C
    ../src/landzo/Landzo_Electromagnetism/: Landzo_Electromagnetism.c
    ../src/landzo/Landzo_GyroAccelerate/: Landzo_GyroAccelerate.c
    ../src/landzo/Landzo_Key/: Landzo_Key.c
    ../src/landzo/Landzo_MeasureSpeed/: Landzo_MeasureSpeed.c
    ../src/landzo/Landzo_Motor/: Landzo_Motor.c
    ../src/landzo/Landzo_NRF24L01/: Landzo_NRF24L01.c
    ../src/landzo/Landzo_OLED/: Landzo_OLED.c
    ../src/landzo/Landzo_Predator/: Landzo_Predator.c
    ../src/landzo/Landzo_SD/: Landzo_SD.c
    ../src/landzo/Landzo_ServoMotor/: Landzo_ServoMotor.c
    ../src/landzo/Landzo_TFTLCD/: Landzo_TFTLCD.c
    ../src/landzo/Landzo_Ultrasonic/: Landzo_Ultrasonic.c
  group System
    ../src/cpu/: crt0.s start.c startup.c vectors.c
    ../src/Driver/system/: system.c
