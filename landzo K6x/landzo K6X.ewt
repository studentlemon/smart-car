<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>mk64f_Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>mk64f_Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>mk60dz_Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>mk60dz_Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>mk60f_Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>mk60f_Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\..\src\App\isr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\App\main.c</name>
    </file>
  </group>
  <group>
    <name>Driver</name>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\adc\K6x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\CAN\K6x_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\delay\K6x_delay.c</name>
      <configuration>
        <name>mk60dz_Release</name>
      </configuration>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\dma\K6x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\Flash\K6x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\FTM\K6x_FTM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\gpio\K6x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\i2c\K6x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\lptmr\K6x_lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\PIT\K6x_PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\SDHC\K6x_sdhc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\spi\K6x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\uart\K6x_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\Wdog\K6x_wdog.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\gpio\port.h</name>
    </file>
  </group>
  <group>
    <name>Include</name>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\include.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\gpio\pin_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\system\systemclock.h</name>
    </file>
  </group>
  <group>
    <name>Landzo module</name>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_1.44TFT\Landzo_1.44TFT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_Calculation\Landzo_Calculation.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_CCD\Landzo_CCD.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_Electromagnetism\Landzo_Electromagnetism.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_GyroAccelerate\Landzo_GyroAccelerate.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_Key\Landzo_Key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_MeasureSpeed\Landzo_MeasureSpeed.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_Motor\Landzo_Motor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_NRF24L01\Landzo_NRF24L01.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_OLED\Landzo_OLED.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_Predator\Landzo_Predator.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_SD\Landzo_SD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_ServoMotor\Landzo_ServoMotor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_TFTLCD\Landzo_TFTLCD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_Ultrasonic\Landzo_Ultrasonic.c</name>
    </file>
  </group>
  <group>
    <name>System</name>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\crt0.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\start.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\startup.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\system\system.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\vectors.c</name>
    </file>
  </group>
</project>


